File: zerocross.sch (KiCad schematic (older format))
At the start: 16 parts, among them J1 OUTPUT, J2 INPUT, Q1 BC847, Q2 BC847, U1 PC817

Commit message: Solder
Connections:
- net labels added: +
